## examples/modbus_tcp/Kconfig
```kconfig
config EXAMPLES_MODBUS_TCP
	tristate "FreeModBus tcp"
	default n
	---help---
		Enable the FreeModBus example tcp
```
